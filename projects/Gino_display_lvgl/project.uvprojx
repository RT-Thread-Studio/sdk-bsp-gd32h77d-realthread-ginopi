# Keil uVision project project.uvprojx, settings and files
target Gino_display_lvgl (6240000::V6.24::ARMCLANG)
  device: GD32H77DIW GigaDevice
  pack: GigaDevice.GD32H77x_78x_DFP.0.6.1
  cpu: IRAM(0x24000000,0x000C0000) IRAM2(0x00000000,0x00020000) IROM(0x08010000,0x001F0000) IROM2(0x08200000,0x0780000) XRAM(0x20000000,0x00040000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, GD32H77DXW, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __RTTHREAD__
  c include: packages\LVGL-latest\src\stdlib\builtin;packages\LVGL-latest\src\widgets\arc;packages\LVGL-latest\src\widgets\tabview;packages\LVGL-latest\demos\music\assets;packages\LVGL-latest\src\draw\sw\blend;packages\LVGL-latest\src\draw\sw;packages\LVGL-latest\src\layouts\flex;packages\LVGL-latest\src\widgets\gif;packages\LVGL-latest\src\widgets\ime;packages\LVGL-latest\src\misc;packages\LVGL-latest\src\draw\sw\arm2d;rt-thread\components\drivers\include;packages\LVGL-latest\src\libs\bin_decoder;packages\LVGL-latest\env_support\rt-thread;packages\LVGL-latest\src\font\freetype;packages\LVGL-latest\src\layouts;packages\LVGL-latest\demos;rt-thread\libcpu\arm\common;packages\LVGL-latest\src\tick;packages\LVGL-latest\src\widgets\3dtexture;packages\LVGL-latest\src\libs\tiny_ttf;packages\LVGL-latest\src\widgets\gstreamer;packages\LVGL-latest\src\widgets\menu;rt-thread\components\drivers\include;libraries\Board_Drivers;packages\LVGL-latest\src\draw;rt-thread\include;packages\LVGL-latest\src\widgets\msgbox;rt-thread\components\libc\compilers\common\extension;applications;rt-thread\components\drivers\touch;packages\LVGL-latest\src\widgets\tileview;packages\LVGL-latest\src\widgets\span;packages\LVGL-latest\src\font\binfont_loader;libraries\gd32-arm-cmsis-latest\GD32H77x_78x;packages\LVGL-latest\src\draw\convert\helium;packages\LVGL-latest\src\widgets\roller;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\posix\ipc;libraries\gd32-arm-series-latest\GD32H77x_78x\GD32H77x_78x_standard_peripheral\Include;packages\LVGL-latest\src\widgets\buttonmatrix;packages\LVGL-latest\src\widgets\list;packages\LVGL-latest\src\libs\fsdrv;packages\LVGL-latest\src\widgets\spinbox;rt-thread\components\drivers\include;packages\LVGL-latest\src\widgets\ffmpeg;packages\LVGL-latest\src\osal;packages\LVGL-latest\src\widgets\checkbox;libraries\gd32_drivers;packages\LVGL-latest\src\themes\mono;rt-thread\libcpu\arm\cortex-m7;packages\LVGL-latest\src\widgets\qrcode;packages\LVGL-latest\src\image\svg;packages\LVGL-latest\src\font\fmt_txt;packages\LVGL-latest\src\widgets\calendar;packages\LVGL-latest\src\widgets\label;rt-thread\components\drivers\include;libraries\gd32_drivers\config;rt-thread\components\libc\posix\io\poll;packages\LVGL-latest\src\widgets\lottie;packages\LVGL-latest\src\draw\convert\neon;packages\LVGL-latest\src\widgets\image;packages\LVGL-latest\src\widgets\textarea;packages\LVGL-latest\src\debugging\sysmon;rt-thread\components\drivers\smp_call;.;packages\gt911-latest\inc;packages\LVGL-latest\src\widgets\slider;packages\LVGL-latest\src\widgets\table;packages\LVGL-latest\src\widgets\win;packages\LVGL-latest\src\widgets\spinner;packages\LVGL-latest\src\widgets\line;packages\LVGL-latest\src\widgets\objx_templ;packages\LVGL-latest\demos\music;rt-thread\components\drivers\include;packages\LVGL-latest\src\draw\sw\blend\arm2d;packages\LVGL-latest\src\widgets\bar;packages\LVGL-latest\src\widgets\chart;rt-thread\components\libc\posix\io\eventfd;packages\LVGL-latest\src\widgets\imagebutton;packages\LVGL-latest\src\others\file_explorer;packages\LVGL-latest\src\misc\cache;packages\LVGL-latest\src\font\imgfont;packages\LVGL-latest\src\widgets\led;rt-thread\components\libc\posix\io\epoll;rt-thread\components\drivers\include;libraries\gd32_drivers\usb;packages\LVGL-latest\src\image;packages\LVGL-latest\src\draw\convert;packages\LVGL-latest\src\font;rt-thread\components\finsh;packages\LVGL-latest\src\layouts\grid;packages\LVGL-latest\src\themes\simple;packages\LVGL-latest\src\widgets\keyboard;packages\LVGL-latest\src\indev;packages\LVGL-latest\src\themes\default;rt-thread\components\drivers\include;rt-thread\components\net\utest;packages\LVGL-latest\src\display;packages\LVGL-latest\src\misc\cache\class;packages\LVGL-latest\src\others\fragment;packages\LVGL-latest\src\widgets\animimage;packages\LVGL-latest\src\misc\cache\instance;packages\LVGL-latest\src\libs\bmp;packages\LVGL-latest\src;packages\LVGL-latest\src\widgets\dropdown;packages\LVGL-latest\src\fs;packages\LVGL-latest\src\widgets\scale;libraries\gd32-arm-cmsis-latest\GD32H77x_78x\GD\GD32H77x_78x\Include;rt-thread\components\drivers\include;packages\LVGL-latest\src\core;packages\LVGL-latest\src\others\translation;packages\LVGL-latest\src\widgets\barcode;packages\LVGL-latest\src\widgets\button;rt-thread\components\drivers\phy;packages\LVGL-latest\src\widgets\switch;packages\LVGL-latest\src\widgets\canvas;packages\LVGL-latest\src\widgets\property;rt-thread\components\drivers\include;packages\LVGL-latest\src\widgets\arclabel;packages\LVGL-latest\src\stdlib;packages\LVGL-latest\src\themes;packages\LVGL-latest\src\draw\sifli\epic;packages\LVGL-latest\src\font\font_manager;rt-thread\components\libc\compilers\common\include
  library: MicroLIB
  memory RVCT4: ROM 0x08010000 size 0x001F0000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xc0000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: device_probe.c lv_port.c main.c
  group Board_Drivers
    libraries/Board_Drivers/: board.c drv_sdram_port.c drv_lcd.c drv_gt911.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: rt_drv_pwm.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/touch/: dev_touch.c
  group Drivers
    libraries/gd32_drivers/: drv_gpio.c drv_usart.c drv_hard_i2c.c drv_pwm.c drv_sdram.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group gt911
    packages/gt911-latest/src/: gt911.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/ARM/: startup_gd32h77x_78x.s
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/: system_gd32h77x_78x.c
    libraries/gd32-arm-series-latest/GD32H77x_78x/GD32H77x_78x_standard_peripheral/Source/: gd32h77x_78x_dma.c gd32h77x_78x_dsi.c gd32h77x_78x_exmc.c gd32h77x_78x_exti.c gd32h77x_78x_gpio.c gd32h77x_78x_i2c.c gd32h77x_78x_ipa.c gd32h77x_78x_misc.c gd32h77x_78x_pmu.c gd32h77x_78x_rcu.c gd32h77x_78x_syscfg.c gd32h77x_78x_timer.c gd32h77x_78x_tli.c gd32h77x_78x_usart.c
  group LVGL
    packages/LVGL-latest/src/: lv_conf_check.c lv_init.c
    packages/LVGL-latest/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    packages/LVGL-latest/src/display/: lv_display.c
    packages/LVGL-latest/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    packages/LVGL-latest/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    packages/LVGL-latest/src/fs/: lv_fs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    packages/LVGL-latest/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    packages/LVGL-latest/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    packages/LVGL-latest/src/layouts/: lv_layout.c
    packages/LVGL-latest/src/logging/: lv_log.c
    packages/LVGL-latest/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    packages/LVGL-latest/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    packages/LVGL-latest/src/stdlib/: lv_mem.c
    packages/LVGL-latest/src/themes/: lv_theme.c
    packages/LVGL-latest/src/tick/: lv_tick.c
    packages/LVGL-latest/src/debugging/sysmon/: lv_sysmon.c
    packages/LVGL-latest/src/draw/convert/: lv_draw_buf_convert.c
    packages/LVGL-latest/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    packages/LVGL-latest/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    packages/LVGL-latest/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    packages/LVGL-latest/src/draw/sifli/epic/: lv_draw_buf_sifli_epic.c lv_draw_sifli_epic.c lv_draw_sifli_epic_border.c lv_draw_sifli_epic_fill.c lv_draw_sifli_epic_img.c lv_draw_sifli_epic_label.c lv_draw_sifli_epic_layer.c lv_sifli_epic_cfg.c lv_sifli_epic_osa.c lv_sifli_epic_utils.c
    packages/LVGL-latest/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    packages/LVGL-latest/src/font/binfont_loader/: lv_binfont_loader.c
    packages/LVGL-latest/src/font/fmt_txt/: lv_font_fmt_txt.c
    packages/LVGL-latest/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    packages/LVGL-latest/src/font/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    packages/LVGL-latest/src/font/imgfont/: lv_imgfont.c
    packages/LVGL-latest/src/font/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-latest/src/image/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    packages/LVGL-latest/src/layouts/flex/: lv_flex.c
    packages/LVGL-latest/src/layouts/grid/: lv_grid.c
    packages/LVGL-latest/src/misc/cache/: lv_cache.c lv_cache_entry.c
    packages/LVGL-latest/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    packages/LVGL-latest/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    packages/LVGL-latest/src/others/file_explorer/: lv_file_explorer.c
    packages/LVGL-latest/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-latest/src/others/translation/: lv_translation.c
    packages/LVGL-latest/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    packages/LVGL-latest/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    packages/LVGL-latest/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    packages/LVGL-latest/src/themes/default/: lv_theme_default.c
    packages/LVGL-latest/src/themes/mono/: lv_theme_mono.c
    packages/LVGL-latest/src/themes/simple/: lv_theme_simple.c
    packages/LVGL-latest/src/widgets/3dtexture/: lv_3dtexture.c
    packages/LVGL-latest/src/widgets/animimage/: lv_animimage.c
    packages/LVGL-latest/src/widgets/arc/: lv_arc.c
    packages/LVGL-latest/src/widgets/arclabel/: lv_arclabel.c
    packages/LVGL-latest/src/widgets/bar/: lv_bar.c
    packages/LVGL-latest/src/widgets/barcode/: lv_barcode.c
    packages/LVGL-latest/src/widgets/button/: lv_button.c
    packages/LVGL-latest/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    packages/LVGL-latest/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-latest/src/widgets/canvas/: lv_canvas.c
    packages/LVGL-latest/src/widgets/chart/: lv_chart.c
    packages/LVGL-latest/src/widgets/checkbox/: lv_checkbox.c
    packages/LVGL-latest/src/widgets/dropdown/: lv_dropdown.c
    packages/LVGL-latest/src/widgets/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-latest/src/widgets/gif/: lv_gif.c
    packages/LVGL-latest/src/widgets/gstreamer/: lv_gstreamer.c
    packages/LVGL-latest/src/widgets/image/: lv_image.c
    packages/LVGL-latest/src/widgets/imagebutton/: lv_imagebutton.c
    packages/LVGL-latest/src/widgets/ime/: lv_ime_pinyin.c
    packages/LVGL-latest/src/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-latest/src/widgets/label/: lv_label.c
    packages/LVGL-latest/src/widgets/led/: lv_led.c
    packages/LVGL-latest/src/widgets/line/: lv_line.c
    packages/LVGL-latest/src/widgets/list/: lv_list.c
    packages/LVGL-latest/src/widgets/lottie/: lv_lottie.c
    packages/LVGL-latest/src/widgets/menu/: lv_menu.c
    packages/LVGL-latest/src/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-latest/src/widgets/objx_templ/: lv_objx_templ.c
    packages/LVGL-latest/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    packages/LVGL-latest/src/widgets/qrcode/: lv_qrcode.c
    packages/LVGL-latest/src/widgets/roller/: lv_roller.c
    packages/LVGL-latest/src/widgets/scale/: lv_scale.c
    packages/LVGL-latest/src/widgets/slider/: lv_slider.c
    packages/LVGL-latest/src/widgets/span/: lv_span.c
    packages/LVGL-latest/src/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-latest/src/widgets/spinner/: lv_spinner.c
    packages/LVGL-latest/src/widgets/switch/: lv_switch.c
    packages/LVGL-latest/src/widgets/table/: lv_table.c
    packages/LVGL-latest/src/widgets/tabview/: lv_tabview.c
    packages/LVGL-latest/src/widgets/textarea/: lv_textarea.c
    packages/LVGL-latest/src/widgets/tileview/: lv_tileview.c
    packages/LVGL-latest/src/widgets/win/: lv_win.c
    packages/LVGL-latest/demos/: lv_demos.c
    packages/LVGL-latest/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    packages/LVGL-latest/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
  group LVGL-port
    packages/LVGL-latest/env_support/rt-thread/: lv_rt_thread_port.c
