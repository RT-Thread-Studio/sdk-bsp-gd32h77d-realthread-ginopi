# Keil uVision project project.uvprojx, settings and files
target Gino_component_mqtt (6240000::V6.24::ARMCLANG)
  device: GD32H77DIW GigaDevice
  pack: GigaDevice.GD32H77x_78x_DFP.0.6.1
  cpu: IRAM(0x24000000,0x000C0000) IRAM2(0x00000000,0x00020000) IROM(0x08010000,0x001F0000) IROM2(0x08200000,0x0780000) XRAM(0x20000000,0x00040000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __RTTHREAD__, GD32H77DXW, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, USE_STDPERIPH_DRIVER, RT_USING_LIBC, RT_USING_ARMLIBC
  c include: rt-thread\components\drivers\include;rt-thread\components\drivers\smp_call;rt-thread\components\net\at\include;libraries\Board_Drivers;rt-thread\components\libc\posix\io\eventfd;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\libc\posix\io\epoll;applications;packages\kawaii-mqtt-latest\mqtt;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;rt-thread\components\net\sal\include;rt-thread\components\libc\compilers\common\include;rt-thread\components\net\sal\impl;rt-thread\components\net\utest;rt-thread\components\net\at\at_socket;packages\at_device-latest\inc;packages\kawaii-mqtt-latest\common\log;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;rt-thread\components\drivers\include;.;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\socket;packages\kawaii-mqtt-latest\mqttclient;libraries\gd32_drivers\config;libraries\gd32_drivers;packages\kawaii-mqtt-latest\platform\RT-Thread;rt-thread\components\net\netdev\include;rt-thread\include;libraries\gd32-arm-cmsis-latest\GD32H77x_78x\GD\GD32H77x_78x\Include;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\libc\compilers\common\extension;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;libraries\gd32_drivers\usb;rt-thread\components\finsh;packages\kawaii-mqtt-latest\network;libraries\gd32-arm-series-latest\GD32H77x_78x\GD32H77x_78x_standard_peripheral\Include;packages\kawaii-mqtt-latest\common;packages\at_device-latest\class\gd32vw553;libraries\gd32-arm-cmsis-latest\GD32H77x_78x;rt-thread\components\drivers\phy
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x1f0000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xc0000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: device_probe.c gd32vw553_mqtt_demo.c main.c
    packages/at_device-latest/samples/: at_sample_gd32vw553.c
  group AT
    rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/class/gd32vw553/: at_device_gd32vw553.c at_socket_gd32vw553.c
  group Board_Drivers
    libraries/Board_Drivers/: board.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group kawaii_mqtt
    packages/kawaii-mqtt-latest/common/: mqtt_list.c random.c
    packages/kawaii-mqtt-latest/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/kawaii-mqtt-latest/mqttclient/: mqttclient.c
    packages/kawaii-mqtt-latest/network/: nettype_tcp.c nettype_tls.c network.c
    packages/kawaii-mqtt-latest/platform/RT-Thread/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
    packages/kawaii-mqtt-latest/common/log/: fifo.c format.c salof.c
    packages/kawaii-mqtt-latest/common/log/arch/rt-thread/: arch.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/ARM/: startup_gd32h77x_78x.s
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/: system_gd32h77x_78x.c
    libraries/gd32-arm-series-latest/GD32H77x_78x/GD32H77x_78x_standard_peripheral/Source/: gd32h77x_78x_dma.c gd32h77x_78x_exti.c gd32h77x_78x_gpio.c gd32h77x_78x_misc.c gd32h77x_78x_pmu.c gd32h77x_78x_rcu.c gd32h77x_78x_syscfg.c gd32h77x_78x_usart.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/socket/: net_netdb.c
    rt-thread/components/net/sal/src/: sal_socket.c
