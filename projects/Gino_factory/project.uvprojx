# Keil uVision project project.uvprojx, settings and files
target Gino_factory (6240000::V6.24::ARMCLANG)
  device: GD32H77DIW GigaDevice
  pack: GigaDevice.GD32H77x_78x_DFP.0.6.1
  cpu: IRAM(0x24000000,0x000C0000) IRAM2(0x00000000,0x00020000) IROM(0x08010000,0x001F0000) IROM2(0x08200000,0x0780000) XRAM(0x20000000,0x00040000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, GD32H77DXW, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, __STDC_LIMIT_MACROS, __RTTHREAD__
  c include: rt-thread\components\net\at\include;packages\LVGL-latest\src\draw;packages\LVGL-latest\src\draw\sw\blend\arm2d;rt-thread\components\legacy\usb\usbhost\include;rt-thread\components\drivers\include;applications;packages\kawaii-mqtt-latest\network;packages\LVGL-latest\src\widgets\imagebutton;packages\i2c-tools-v1.0.0;packages\LVGL-latest\src\draw\sw\arm2d;packages\LVGL-latest\src\widgets\qrcode;packages\LVGL-latest\src\widgets\switch;rt-thread\components\libc\compilers\common\extension;packages\LVGL-latest\src\others\file_explorer;libraries\gd32_drivers\usb;packages\LVGL-latest\src\themes\simple;packages\LVGL-latest\src\widgets\led;packages\gt911-latest\inc;packages\LVGL-latest\src\osal;rt-thread\components\drivers\phy;packages\LVGL-latest\src\themes\default;packages\LVGL-latest\src\widgets\checkbox;packages\LVGL-latest\src\stdlib\builtin;packages\LVGL-latest\src\stdlib;rt-thread\components\drivers\include;packages\LVGL-latest\src\draw\sifli\epic;packages\LVGL-latest\src\widgets\3dtexture;rt-thread\components\libc\compilers\common\include;packages\LVGL-latest\src\widgets\button;packages\LVGL-latest\src\widgets\tabview;rt-thread\components\legacy\usb\usbdevice;packages\LVGL-latest\src\fs;rt-thread\components\drivers\include;packages\LVGL-latest\src\widgets\barcode;rt-thread\components\drivers\smp_call;packages\LVGL-latest\src\themes\mono;rt-thread\components\dfs\dfs_v1\filesystems\elmfat;packages\LVGL-latest\src\font\freetype;rt-thread\components\fal\inc;packages\LVGL-latest\src\draw\convert\helium;packages\LVGL-latest\src\widgets\chart;packages\LVGL-latest\src\draw\convert\neon;rt-thread\components\drivers\spi;packages\LVGL-latest\src\themes;packages\at_device-latest\inc;packages\LVGL-latest\src\others\fragment;packages\i2c-tools-v1.0.0\src;packages\LVGL-latest\src\widgets\textarea;packages\LVGL-latest\src\widgets\objx_templ;packages\LVGL-latest\src\font\binfont_loader;libraries\gd32-arm-cmsis-latest\GD32H77x_78x;rt-thread\components\drivers\include;rt-thread\components\net\sal\include\dfs_net;packages\LVGL-latest\env_support\rt-thread;packages\LVGL-latest\src\widgets\label;packages\LVGL-latest\src\libs\bmp;packages\LVGL-latest\src\widgets\dropdown;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\kawaii-mqtt-latest\common;libraries\Board_Drivers\ports\camera\sensors;packages\LVGL-latest\src\layouts;packages\kawaii-mqtt-latest\platform\RT-Thread;rt-thread\components\libc\posix\io\poll;packages\LVGL-latest\src\widgets\buttonmatrix;packages\LVGL-latest\src\widgets\menu;rt-thread\components\dfs\dfs_v1\include;rt-thread\components\net\sal\include;packages\LVGL-latest\src\others\translation;packages\LVGL-latest\src\font;packages\LVGL-latest\src\widgets\msgbox;packages\LVGL-latest\src\widgets\span;packages\LVGL-latest\src\libs\bin_decoder;rt-thread\components\libc\posix\ipc;packages\LVGL-latest\src\widgets\line;packages\LVGL-latest\src\widgets\list;packages\kawaii-mqtt-latest\common\log;packages\LVGL-latest\src\widgets\image;packages\kawaii-mqtt-latest\mqttclient;packages\LVGL-latest\src\widgets\arclabel;packages\LVGL-latest\src\widgets\calendar;rt-thread\components\finsh;packages\LVGL-latest\src\widgets\property;rt-thread\components\legacy\include;packages\LVGL-latest\src\font\fmt_txt;rt-thread\components\net\utest;packages\LVGL-latest\src\display;packages\LVGL-latest\src\draw\sw\blend;packages\LVGL-latest\src\widgets\arc;packages\LVGL-latest\src\image;rt-thread\components\legacy\usb\usbhost\class;rt-thread\components\net\at\at_socket;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;packages\LVGL-latest\src\widgets\scale;rt-thread\components\net\sal\include\socket\sys_socket;.;packages\LVGL-latest\src\libs\tiny_ttf;packages\LVGL-latest\src\misc\cache;rt-thread\components\net\lwip\lwip-2.0.3\src\include;packages\LVGL-latest\src\widgets\ime;libraries\gd32_drivers;rt-thread\libcpu\arm\common;packages\LVGL-latest\src\draw\convert;rt-thread\components\drivers\include;libraries\gd32-arm-series-latest\GD32H77x_78x\GD32H77x_78x_standard_peripheral\Include;packages\LVGL-latest\src\misc\cache\instance;packages\LVGL-latest\src\widgets\spinner;rt-thread\components\net\netdev\include;packages\LVGL-latest\src\misc\cache\class;packages\kawaii-mqtt-latest\mqtt;packages\LVGL-latest\src\widgets\keyboard;rt-thread\components\drivers\include;packages\LVGL-latest\src\widgets\gstreamer;packages\LVGL-latest\src;packages\LVGL-latest\src\widgets\animimage;packages\LVGL-latest\src\layouts\flex;libraries\Board_Drivers\ports\camera;packages\LVGL-latest\src\widgets\spinbox;libraries\gd32-arm-cmsis-latest\GD32H77x_78x\GD\GD32H77x_78x\Include;packages\LVGL-latest\src\core;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\dfs\dfs_v1\filesystems\devfs;packages\LVGL-latest\src\widgets\tileview;rt-thread\components\legacy\usb\usbhost\core;packages\LVGL-latest\src\indev;packages\LVGL-latest\src\widgets\ffmpeg;rt-thread\components\drivers\include;packages\LVGL-latest\src\debugging\sysmon;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;rt-thread\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-latest\src\widgets\slider;packages\LVGL-latest\src\draw\sw;rt-thread\components\drivers\include;rt-thread\components\dfs\dfs_v1\filesystems\romfs;packages\LVGL-latest\src\widgets\table;rt-thread\components\net\sal\include\socket;packages\LVGL-latest\src\widgets\roller;packages\at_device-latest\class\gd32vw553;rt-thread\components\drivers\include;packages\LVGL-latest\src\layouts\grid;rt-thread\components\legacy\usb\usbhost;rt-thread\components\drivers\include;packages\LVGL-latest\src\widgets\win;packages\LVGL-latest\src\widgets\lottie;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\posix\io\eventfd;packages\LVGL-latest\src\libs\fsdrv;packages\LVGL-latest\src\image\svg;rt-thread\components\net\lwip\port;rt-thread\libcpu\arm\cortex-m7;packages\LVGL-latest\src\font\font_manager;packages\LVGL-latest\src\widgets\canvas;rt-thread\components\net\sal\impl;packages\LVGL-latest\src\tick;rt-thread\components\drivers\include;packages\LVGL-latest\src\widgets\bar;rt-thread\components\drivers\include;packages\LVGL-latest\src\widgets\gif;libraries\gd32_drivers\config;libraries\Board_Drivers;packages\LVGL-latest\src\font\imgfont;packages\LVGL-latest\src\misc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x1f0000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xc0000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: board_demo.c board_demo_backend.c device_probe.c gd32vw553_mqtt_demo.c lv_port.c main.c ov7670_preview.c pwm_dual_test.c
    packages/at_device-latest/samples/: at_sample_gd32vw553.c
  group AT
    rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/class/gd32vw553/: at_device_gd32vw553.c at_socket_gd32vw553.c
  group Board_Drivers
    libraries/Board_Drivers/: board.c drv_enet.c drv_sdram_port.c drv_lcd.c drv_gt911.c drv_ov7670.c drv_qspi_flash.c drv_filesystem.c
  group CameraPort
    libraries/Board_Drivers/ports/camera/: cambus.c sensor.c
    libraries/Board_Drivers/ports/camera/sensors/: ov7670.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/block/: blk.c blk_dev.c blk_dfs.c blk_partition.c
    rt-thread/components/drivers/block/partitions/: dfs.c efi.c
    rt-thread/components/drivers/can/: dev_can.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: rt_drv_pwm.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c
    rt-thread/components/drivers/touch/: dev_touch.c
  group Drivers
    libraries/gd32_drivers/: drv_gpio.c drv_usart.c drv_hard_i2c.c drv_spi.c drv_ospi.c drv_sdio.c drv_pwm.c drv_can.c drv_sdram.c
    libraries/gd32_drivers/usb/: drv_usb_core.c gd32h7_usb_hw.c drv_otghs_dev.c drv_usb_dev.c drv_usbd_int.c drv_otghs_host.c drv_usb_host.c drv_usbh_int.c drv_usbh_pipe.c drv_usbh_trans.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group Filesystem
    rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group gt911
    packages/gt911-latest/src/: gt911.c
  group i2c-tools
    packages/i2c-tools-v1.0.0/src/: i2c_utils.c i2c_tools.c
  group kawaii_mqtt
    packages/kawaii-mqtt-latest/common/: mqtt_list.c random.c
    packages/kawaii-mqtt-latest/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/kawaii-mqtt-latest/mqttclient/: mqttclient.c
    packages/kawaii-mqtt-latest/network/: nettype_tcp.c nettype_tls.c network.c
    packages/kawaii-mqtt-latest/platform/RT-Thread/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
    packages/kawaii-mqtt-latest/common/log/: fifo.c format.c salof.c
    packages/kawaii-mqtt-latest/common/log/arch/rt-thread/: arch.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/ARM/: startup_gd32h77x_78x.s
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/: system_gd32h77x_78x.c
    libraries/gd32-arm-series-latest/GD32H77x_78x/GD32H77x_78x_standard_peripheral/Source/: gd32h77x_78x_can.c gd32h77x_78x_dci.c gd32h77x_78x_dma.c gd32h77x_78x_dsi.c gd32h77x_78x_enet.c gd32h77x_78x_exmc.c gd32h77x_78x_exti.c gd32h77x_78x_gpio.c gd32h77x_78x_i2c.c gd32h77x_78x_ipa.c gd32h77x_78x_mdma.c gd32h77x_78x_misc.c gd32h77x_78x_ospi.c gd32h77x_78x_ospim.c gd32h77x_78x_pmu.c gd32h77x_78x_rcu.c gd32h77x_78x_sdio.c gd32h77x_78x_spi.c gd32h77x_78x_syscfg.c gd32h77x_78x_timer.c gd32h77x_78x_tli.c gd32h77x_78x_usart.c
  group LVGL
    packages/LVGL-latest/src/: lv_conf_check.c lv_init.c
    packages/LVGL-latest/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    packages/LVGL-latest/src/display/: lv_display.c
    packages/LVGL-latest/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    packages/LVGL-latest/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    packages/LVGL-latest/src/fs/: lv_fs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    packages/LVGL-latest/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    packages/LVGL-latest/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    packages/LVGL-latest/src/layouts/: lv_layout.c
    packages/LVGL-latest/src/logging/: lv_log.c
    packages/LVGL-latest/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    packages/LVGL-latest/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    packages/LVGL-latest/src/stdlib/: lv_mem.c
    packages/LVGL-latest/src/themes/: lv_theme.c
    packages/LVGL-latest/src/tick/: lv_tick.c
    packages/LVGL-latest/src/debugging/sysmon/: lv_sysmon.c
    packages/LVGL-latest/src/draw/convert/: lv_draw_buf_convert.c
    packages/LVGL-latest/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    packages/LVGL-latest/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    packages/LVGL-latest/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    packages/LVGL-latest/src/draw/sifli/epic/: lv_draw_buf_sifli_epic.c lv_draw_sifli_epic.c lv_draw_sifli_epic_border.c lv_draw_sifli_epic_fill.c lv_draw_sifli_epic_img.c lv_draw_sifli_epic_label.c lv_draw_sifli_epic_layer.c lv_sifli_epic_cfg.c lv_sifli_epic_osa.c lv_sifli_epic_utils.c
    packages/LVGL-latest/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    packages/LVGL-latest/src/font/binfont_loader/: lv_binfont_loader.c
    packages/LVGL-latest/src/font/fmt_txt/: lv_font_fmt_txt.c
    packages/LVGL-latest/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    packages/LVGL-latest/src/font/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    packages/LVGL-latest/src/font/imgfont/: lv_imgfont.c
    packages/LVGL-latest/src/font/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-latest/src/image/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    packages/LVGL-latest/src/layouts/flex/: lv_flex.c
    packages/LVGL-latest/src/layouts/grid/: lv_grid.c
    packages/LVGL-latest/src/misc/cache/: lv_cache.c lv_cache_entry.c
    packages/LVGL-latest/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    packages/LVGL-latest/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    packages/LVGL-latest/src/others/file_explorer/: lv_file_explorer.c
    packages/LVGL-latest/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-latest/src/others/translation/: lv_translation.c
    packages/LVGL-latest/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    packages/LVGL-latest/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    packages/LVGL-latest/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    packages/LVGL-latest/src/themes/default/: lv_theme_default.c
    packages/LVGL-latest/src/themes/mono/: lv_theme_mono.c
    packages/LVGL-latest/src/themes/simple/: lv_theme_simple.c
    packages/LVGL-latest/src/widgets/3dtexture/: lv_3dtexture.c
    packages/LVGL-latest/src/widgets/animimage/: lv_animimage.c
    packages/LVGL-latest/src/widgets/arc/: lv_arc.c
    packages/LVGL-latest/src/widgets/arclabel/: lv_arclabel.c
    packages/LVGL-latest/src/widgets/bar/: lv_bar.c
    packages/LVGL-latest/src/widgets/barcode/: lv_barcode.c
    packages/LVGL-latest/src/widgets/button/: lv_button.c
    packages/LVGL-latest/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    packages/LVGL-latest/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-latest/src/widgets/canvas/: lv_canvas.c
    packages/LVGL-latest/src/widgets/chart/: lv_chart.c
    packages/LVGL-latest/src/widgets/checkbox/: lv_checkbox.c
    packages/LVGL-latest/src/widgets/dropdown/: lv_dropdown.c
    packages/LVGL-latest/src/widgets/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-latest/src/widgets/gif/: lv_gif.c
    packages/LVGL-latest/src/widgets/gstreamer/: lv_gstreamer.c
    packages/LVGL-latest/src/widgets/image/: lv_image.c
    packages/LVGL-latest/src/widgets/imagebutton/: lv_imagebutton.c
    packages/LVGL-latest/src/widgets/ime/: lv_ime_pinyin.c
    packages/LVGL-latest/src/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-latest/src/widgets/label/: lv_label.c
    packages/LVGL-latest/src/widgets/led/: lv_led.c
    packages/LVGL-latest/src/widgets/line/: lv_line.c
    packages/LVGL-latest/src/widgets/list/: lv_list.c
    packages/LVGL-latest/src/widgets/lottie/: lv_lottie.c
    packages/LVGL-latest/src/widgets/menu/: lv_menu.c
    packages/LVGL-latest/src/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-latest/src/widgets/objx_templ/: lv_objx_templ.c
    packages/LVGL-latest/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    packages/LVGL-latest/src/widgets/qrcode/: lv_qrcode.c
    packages/LVGL-latest/src/widgets/roller/: lv_roller.c
    packages/LVGL-latest/src/widgets/scale/: lv_scale.c
    packages/LVGL-latest/src/widgets/slider/: lv_slider.c
    packages/LVGL-latest/src/widgets/span/: lv_span.c
    packages/LVGL-latest/src/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-latest/src/widgets/spinner/: lv_spinner.c
    packages/LVGL-latest/src/widgets/switch/: lv_switch.c
    packages/LVGL-latest/src/widgets/table/: lv_table.c
    packages/LVGL-latest/src/widgets/tabview/: lv_tabview.c
    packages/LVGL-latest/src/widgets/textarea/: lv_textarea.c
    packages/LVGL-latest/src/widgets/tileview/: lv_tileview.c
    packages/LVGL-latest/src/widgets/win/: lv_win.c
  group LVGL-port
    packages/LVGL-latest/env_support/rt-thread/: lv_rt_thread_port.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group rt_usbd
    rt-thread/components/legacy/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    rt-thread/components/legacy/usb/usbdevice/class/: cdc_vcom.c
  group rt_usbh
    rt-thread/components/legacy/usb/usbhost/core/: usbhost_core.c driver.c usbhost.c hub.c
    rt-thread/components/legacy/usb/usbhost/class/: mass.c udisk.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_at.c af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
