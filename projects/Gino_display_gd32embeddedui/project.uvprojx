# Keil uVision project project.uvprojx, settings and files
target Gino_display_gd32embeddedui (6240000::V6.24::ARMCLANG)
  device: GD32H77DIW GigaDevice
  pack: GigaDevice.GD32H77x_78x_DFP.0.6.1
  cpu: IRAM(0x24000000,0x000C0000) IRAM2(0x00000000,0x00020000) IROM(0x08010000,0x001F0000) IROM2(0x08200000,0x0780000) XRAM(0x20000000,0x00040000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32H77DXW, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, __RTTHREAD__, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS
  c include: rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\widgets\span;packages\LVGL-v8.3.11\src\extra\widgets\menu;rt-thread\components\net\netdev\include;libraries\gd32-arm-cmsis-latest\GD32H77x_78x\GD\GD32H77x_78x\Include;.;packages\LVGL-v8.3.11\src\extra\widgets\list;packages\GD32EmbeddedUI-demos\generated\config;rt-thread\components\drivers\touch;packages\LVGL-v8.3.11\src\extra\widgets\meter;rt-thread\components\net\sal\include\socket;packages\kawaii-mqtt-latest\platform\RT-Thread;applications;packages\LVGL-v8.3.11\src\misc;packages\LVGL-v8.3.11\src\widgets;rt-thread\components\libc\compilers\common\extension;packages\LVGL-v8.3.11\src\extra\widgets\spinner;rt-thread\components\finsh;packages\kawaii-mqtt-latest\common;packages\at_device-latest\class\gd32vw553;packages\LVGL-v8.3.11\src\extra\widgets\tileview;rt-thread\components\net\sal\impl;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\widgets\calendar;packages\kawaii-mqtt-latest\common\log;packages\GD32EmbeddedUI-demos\generated;packages\LVGL-v8.3.11\src\extra\libs\png;packages\LVGL-v8.3.11\src\extra\widgets\colorwheel;libraries\gd32-arm-cmsis-latest\GD32H77x_78x;packages\kawaii-mqtt-latest\mqtt;packages\LVGL-v8.3.11\src\extra\others\gridnav;packages\GD32EmbeddedUI-demos\custom;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\epoll;packages\LVGL-v8.3.11\src\extra\themes\basic;packages\LVGL-v8.3.11\src\draw\nxp\pxp;packages\LVGL-v8.3.11\src\draw\stm32_dma2d;packages\LVGL-v8.3.11\src\draw;libraries\gd32_drivers\usb;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\posix\io\eventfd;packages\LVGL-v8.3.11\src\extra\others\monkey;packages\LVGL-v8.3.11\src\extra\layouts\grid;packages\LVGL-v8.3.11\src\extra\libs\gif;rt-thread\libcpu\arm\common;packages\LVGL-v8.3.11\src\extra\others\fragment;packages\LVGL-v8.3.11\src\extra\widgets\led;packages\gt911-latest\inc;libraries\gd32-arm-series-latest\GD32H77x_78x\GD32H77x_78x_standard_peripheral\Include;packages\LVGL-v8.3.11\src\extra\libs\ffmpeg;packages\GD32EmbeddedUI-demos\generated\theme;rt-thread\components\net\utest;packages\LVGL-v8.3.11\src;packages\LVGL-v8.3.11\src\extra\widgets\imgbtn;packages\LVGL-v8.3.11\src\extra\widgets\chart;rt-thread\components\drivers\phy;rt-thread\libcpu\arm\cortex-m7;packages\LVGL-v8.3.11\src\extra\widgets\animimg;packages\LVGL-v8.3.11\src\extra\widgets\tabview;packages\LVGL-v8.3.11\src\extra\themes\mono;rt-thread\components\net\sal\include;packages\LVGL-v8.3.11\src\draw\sw;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\widgets\win;packages\LVGL-v8.3.11\env_support\rt-thread;packages\LVGL-v8.3.11\src\extra\themes\default;packages\LVGL-v8.3.11\src\draw\sdl;packages\kawaii-mqtt-latest\mqttclient;packages\LVGL-v8.3.11\src\extra\others\imgfont;packages\kawaii-mqtt-latest\network;packages\GD32EmbeddedUI-demos\port;rt-thread\components\libc\posix\ipc;packages\LVGL-v8.3.11\src\hal;packages\LVGL-v8.3.11\src\extra;packages\LVGL-v8.3.11\src\extra\libs\qrcode;rt-thread\components\net\at\include;rt-thread\components\drivers\smp_call;packages\at_device-latest\inc;packages\LVGL-v8.3.11\src\extra\libs;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\libs\sjpg;packages\LVGL-v8.3.11\src\extra\others\snapshot;packages\GD32EmbeddedUI-demos\generated\font;packages\LVGL-v8.3.11\src\extra\widgets\msgbox;packages\LVGL-v8.3.11\src\extra\themes;packages\LVGL-v8.3.11\src\draw\swm341_dma2d;packages\GD32EmbeddedUI-demos\generated\image;packages\LVGL-v8.3.11\src\core;libraries\gd32_drivers\config;packages\LVGL-v8.3.11\src\extra\others;packages\LVGL-v8.3.11\src\extra\libs\rlottie;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\libs\freetype;packages\LVGL-v8.3.11\src\extra\libs\fsdrv;packages\LVGL-v8.3.11\src\draw\renesas;packages\GD32EmbeddedUI-demos\generated\screens\mqtt;packages\LVGL-v8.3.11\src\extra\others\ime;packages\LVGL-v8.3.11\src\extra\widgets;packages\LVGL-v8.3.11\src\extra\layouts;packages\LVGL-v8.3.11\src\extra\libs\bmp;packages\LVGL-v8.3.11\src\draw\arm2d;packages\LVGL-v8.3.11\src\font;rt-thread\components\libc\posix\io\poll;packages\LVGL-v8.3.11\src\draw\nxp\vglite;packages\GD32EmbeddedUI-demos\generated\lang;packages\LVGL-v8.3.11\src\extra\libs\tiny_ttf;packages\GD32EmbeddedUI-demos\generated\screens;packages\LVGL-v8.3.11\src\extra\others\msg;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\include;libraries\gd32_drivers;packages\GD32EmbeddedUI-demos;libraries\Board_Drivers;rt-thread\components\net\at\at_socket;packages\LVGL-v8.3.11\src\extra\widgets\keyboard;rt-thread\components\drivers\include;packages\LVGL-v8.3.11\src\extra\layouts\flex;rt-thread\include;packages\LVGL-v8.3.11\src\extra\widgets\spinbox
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x1f0000
  memory RVCT5: ROM 0x8200000 size 0x780000
  memory RVCT6: RAM 0x20000000 size 0x40000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xc0000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: device_probe.c lv_port.c main.c mqtt_ui_port.c
  group AT
    rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/class/gd32vw553/: at_device_gd32vw553.c at_socket_gd32vw553.c
  group Board_Drivers
    libraries/Board_Drivers/: board.c drv_sdram_port.c drv_lcd.c drv_gt911.c
  group CPU
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: rt_drv_pwm.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial.c
    rt-thread/components/drivers/touch/: dev_touch.c
  group Drivers
    libraries/gd32_drivers/: drv_gpio.c drv_usart.c drv_hard_i2c.c drv_pwm.c drv_sdram.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group GD32EmbeddedUI
    packages/GD32EmbeddedUI-demos/generated/: ui_init.c ui_util.c
    packages/GD32EmbeddedUI-demos/generated/font/: font_notosanscjksc_regular_18_b413755d.c font_notosanscjksc_regular_18_b413755d_fb3f.c font_notosanscjksc_regular_28_b49ae336.c font_notosanscjksc_regular_28_b49ae336_fb3f.c
    packages/GD32EmbeddedUI-demos/generated/lang/: aic_lang.c font_list.c
    packages/GD32EmbeddedUI-demos/generated/screens/: event.c
    packages/GD32EmbeddedUI-demos/generated/screens/mqtt/: mqtt.c mqtt_event.c
    packages/GD32EmbeddedUI-demos/generated/theme/: theme.c
    packages/GD32EmbeddedUI-demos/custom/: gui_app.c mqtt_ui_preview.c
  group gt911
    packages/gt911-latest/src/: gt911.c
  group kawaii_mqtt
    packages/kawaii-mqtt-latest/common/: mqtt_list.c random.c
    packages/kawaii-mqtt-latest/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/kawaii-mqtt-latest/mqttclient/: mqttclient.c
    packages/kawaii-mqtt-latest/network/: nettype_tcp.c nettype_tls.c network.c
    packages/kawaii-mqtt-latest/platform/RT-Thread/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
    packages/kawaii-mqtt-latest/common/log/: fifo.c format.c salof.c
    packages/kawaii-mqtt-latest/common/log/arch/rt-thread/: arch.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/ARM/: startup_gd32h77x_78x.s
    libraries/gd32-arm-cmsis-latest/GD32H77x_78x/GD/GD32H77x_78x/Source/: system_gd32h77x_78x.c
    libraries/gd32-arm-series-latest/GD32H77x_78x/GD32H77x_78x_standard_peripheral/Source/: gd32h77x_78x_dma.c gd32h77x_78x_dsi.c gd32h77x_78x_exmc.c gd32h77x_78x_exti.c gd32h77x_78x_gpio.c gd32h77x_78x_i2c.c gd32h77x_78x_ipa.c gd32h77x_78x_misc.c gd32h77x_78x_pmu.c gd32h77x_78x_rcu.c gd32h77x_78x_syscfg.c gd32h77x_78x_timer.c gd32h77x_78x_tli.c gd32h77x_78x_usart.c
  group LVGL
    packages/LVGL-v8.3.11/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    packages/LVGL-v8.3.11/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    packages/LVGL-v8.3.11/src/extra/: lv_extra.c
    packages/LVGL-v8.3.11/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    packages/LVGL-v8.3.11/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-v8.3.11/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    packages/LVGL-v8.3.11/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    packages/LVGL-v8.3.11/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.11/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    packages/LVGL-v8.3.11/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    packages/LVGL-v8.3.11/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.11/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    packages/LVGL-v8.3.11/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.11/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3.11/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    packages/LVGL-v8.3.11/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.11/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.11/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.11/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.11/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.11/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    packages/LVGL-v8.3.11/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.11/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.11/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.11/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.11/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.11/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v8.3.11/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.11/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.11/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.11/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.11/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.11/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.11/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.11/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.11/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.11/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.11/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.11/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.11/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.11/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.11/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.11/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.11/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.11/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.11/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.11/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.11/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.11/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.11/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.11/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.11/src/extra/widgets/win/: lv_win.c
  group LVGL-port
    packages/LVGL-v8.3.11/env_support/rt-thread/: lv_rt_thread_port.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/impl/: af_inet_at.c
    rt-thread/components/net/sal/socket/: net_netdb.c
    rt-thread/components/net/sal/src/: sal_socket.c
